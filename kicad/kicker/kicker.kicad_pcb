# Repository Asg1223/rcj-circuit

File README.md:

# rcj-circuit — RCJ サッカーの電子回路設計

ロボカップジュニア サッカー（インフラレッド）のロボットの電子回路を、KiCad で回路図から基板の発注まで設計できるようになるための教材です。

- サイト：https://asg1223.github.io/rcj-circuit/
- 読む人：RCJ に出る中高生（大学生向けの「もっと深く」つき）
- 理論 3：実装 7、ハンズオン H1〜H8

## 中身

```
rcj-circuit/
├─ zensical.toml              # サイトの設定（Zensical）
├─ docs/                      # 教材の本文（第0〜9部、ハンズオン、計算ツール、付録）
│  └─ assets/                 # 回路図・基板の SVG（KiCad から書き出したもの）
├─ kicad/                     # 教材用の KiCad プロジェクト（すべて架空の構成）
│  ├─ projects.txt            # 自動チェックの対象（ここに書いたものだけ公開リポジトリに置ける）
│  ├─ h1-led/ power/ main/ ir-ring/ motor/ kicker/
├─ templates/team/            # チーム用（非公開）リポジトリのひな形
├─ tools/check_public.py      # うっかり公開チェック
├─ .pre-commit-config.yaml
└─ .github/workflows/
   ├─ docs.yml                # 公開チェック → サイトを GitHub Pages へ
   └─ kicad.yml               # KiCad 10 で ERC・DRC、ガーバー等を Artifacts へ
```

## サイトを手元で見る

```bash
pip install -r requirements-docs.txt
zensical serve
```

## KiCad データ

KiCad 10 で開けます（KiCad 7 形式で保存しているので、開いて保存すると KiCad 10 形式になります）。
push すると GitHub Actions が KiCad 10 で ERC・DRC を走らせ、ガーバー・ドリル・回路図 PDF・部品表を `kicad-outputs` として置きます。

## 自分のチームの基板

公開リポジトリには置かず、非公開の `rcj-circuit-team` に置きます（`templates/team/` をコピー）。
くわしくは docs の「付録：チーム用リポジトリ」を見てください。

## ライセンス

MIT（本文・コード・KiCad データ）

## KiCad design kicad/kicker/kicker.kicad_pcb

Parts:
C1: 1000uF 63V; CP_Radial_D16.0mm_P7.50mm
C2: 0.1uF; C_0805_2012Metric
D1: 緑（充電中）; LED_0805_2012Metric
D2: ES3D（フライバック）; D_SMC
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: 電源基板から (XH 2P); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: メイン基板から (XH 4P); JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: 昇圧モジュール (XH 4P); JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J4: ソレノイド XT30(メス); AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
Q1: P-MOSFET 30V (SOT-23); SOT-23
Q2: BSS138; SOT-23
Q3: N-MOSFET 100V ロジックレベル (DPAK); TO-252-2
R1, R2, R10: 10k; R_0805_2012Metric
R3, R9: 100; R_0805_2012Metric
R4: 100k; R_0805_2012Metric
R5: 10k 1W（放電用）; R_2512_6332Metric
R6: 1M; R_1206_3216Metric
R7: 68k; R_0805_2012Metric
R8: 47k; R_1206_3216Metric
TP1: HV（カバーする）; TestPoint_Loop_D2.50mm_Drill1.0mm
TP2: GND; TestPoint_Loop_D2.50mm_Drill1.0mm

Connections:
/CHG_EN: J2.1, R3.1
/CHG_G: Q2.1 (G), R3.2, R4.1
/HV: C1.1, D2.1 (K), J3.3, J4.2, R5.1, R6.1, R8.1, TP1.1
/HV_SENSE: C2.1, J2.2, R6.2, R7.1
/KICK: J2.3, R9.1
/LED_HV: D1.2 (A), R8.2
/Q1_G: Q1.1 (G), R1.2, R2.1
/Q2_D: Q2.3 (D), R2.2
/Q3_G: Q3.1 (G), R9.2, R10.1
/SOL_N: D2.2 (A), J4.1, Q3.2 (D)
/VBAT: J1.1, Q1.2 (S), R1.1
/VIN_SW: J3.1, Q1.3 (D)
GND: C1.2, C2.2, D1.1 (K), J1.2, J2.4, J3.2, J3.4, Q2.2 (S), Q3.3 (S), R4.2, R5.2, R7.2, R10.2, TP2.1

Notes on the sheet:
1. 充電のオン・オフ（ハイサイド P-MOSFET）
VGS = −VBAT × 10k/(10k+10k) ≒ −6.3 V
2. 昇圧モジュールとコンデンサ
48 V × 68k/(1M+68k) ≒ 3.06 V
3. 放電（ソレノイドを動かす）

Board: 2 copper layers, 64.0 x 52.0 mm, 27 parts (0 on the bottom side), 13 nets.

## KiCad design kicad/h1-led/h1-led.kicad_pcb

Parts:
D1: SS14; D_SMA
D2: 赤; LED_1206_3216Metric
D3: 緑; LED_1206_3216Metric
H1, H2: M3; MountingHole_3.2mm_M3
J1: 電池 (XH 2P); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
R1: 470; R_1206_3216Metric
R2: 1k; R_1206_3216Metric
SW1: 電源スイッチ; SW_DIP_SPSTx01_Slide_9.78x4.72mm_W7.62mm_P2.54mm

Connections:
/LED1_A: D2.2 (A), R1.2
/LED2_A: D3.2 (A), R2.2
/VIN: D1.1 (K), SW1.1
/VIN_RAW: D1.2 (A), J1.1
/VSW: R1.1, R2.1, SW1.2
GND: D2.1 (K), D3.1 (K), J1.2

Notes on the sheet:
LED の電流 = (電源電圧 − LED の電圧) ÷ 抵抗
例：(5 V − 2.0 V) ÷ 470 Ω ≒ 6.4 mA

Board: 2 copper layers, 45.0 x 25.0 mm, 9 parts (0 on the bottom side), 6 nets.

## KiCad design kicad/ir-ring/ir-ring.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9: 0.1uF; C_0805_2012Metric
C10: 10uF; C_1206_3216Metric
H1, H2, H3: M3; MountingHole_3.2mm_M3
J1: メイン基板へ (XH 5P); JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8: 100; R_0805_2012Metric
U1: IR受光 0; Vishay_MINICAST-3Pin
U2: IR受光 1; Vishay_MINICAST-3Pin
U3: IR受光 2; Vishay_MINICAST-3Pin
U4: IR受光 3; Vishay_MINICAST-3Pin
U5: IR受光 4; Vishay_MINICAST-3Pin
U6: IR受光 5; Vishay_MINICAST-3Pin
U7: IR受光 6; Vishay_MINICAST-3Pin
U8: IR受光 7; Vishay_MINICAST-3Pin
U9: 74HC165; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+5V: C9.1, C10.1, J1.3, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, U9.16 (VCC)
/IR0: U1.1 (OUT), U9.14 (D3)
/IR1: U2.1 (OUT), U9.13 (D2)
/IR2: U3.1 (OUT), U9.12 (D1)
/IR3: U4.1 (OUT), U9.11 (D0)
/IR4: U5.1 (OUT), U9.6 (D7)
/IR5: U6.1 (OUT), U9.5 (D6)
/IR6: U7.1 (OUT), U9.4 (D5)
/IR7: U8.1 (OUT), U9.3 (D4)
/IR_CLK: J1.2, U9.2 (CP)
/IR_DATA: J1.4, U9.9 (Q7)
/IR_LOAD: J1.1, U9.1 (~PL)
/VS0: C1.1, R1.2, U1.3 (Vs)
/VS1: C2.1, R2.2, U2.3 (Vs)
/VS2: C3.1, R3.2, U3.3 (Vs)
/VS3: C4.1, R4.2, U4.3 (Vs)
/VS4: C5.1, R5.2, U5.3 (Vs)
/VS5: C6.1, R6.2, U6.3 (Vs)
/VS6: C7.1, R7.2, U7.3 (Vs)
/VS7: C8.1, R8.2, U8.3 (Vs)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J1.5, U1.2 (GND), U2.2 (GND), U3.2 (GND), U4.2 (GND), U5.2 (GND), U6.2 (GND), U7.2 (GND), U8.2 (GND), U9.8 (GND), U9.10 (DS), U9.15 (~CE)

Notes on the sheet:
読み出し：IR_LOAD を L にして入力を取りこみ、H にもどしてから IR_CLK を 8 回
最初に出てくるのは D7（センサ 4）。センサと D の対応は docs の 5-3 の表

Board: 2 copper layers, 90.0 x 90.0 mm, 31 parts (0 on the bottom side), 21 nets.

## KiCad design kicad/main/main.kicad_pcb

Parts:
A1: Arduino Nano 形; Arduino_Nano
C1: 10uF; C_1206_3216Metric
C2: 0.1uF; C_0805_2012Metric
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: 電源基板から (XH 4P); JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2: IR リングへ (XH 5P); JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J3: モータ 1・2 (XH 5P); JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J4: モータ 3・4 (XH 5P); JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J5: キッカー基板へ (XH 4P); JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J6: IMU (PH 4P・3.3 V); JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J7: CoreS3 へ (XH 3P); JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J8: ラインセンサ (XH 3P); JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J9: 審判モジュール (2.54 mm); PinHeader_1x02_P2.54mm_Vertical
Q1, Q2: BSS138; SOT-23
R1, R2, R3, R4: 10k; R_0805_2012Metric
R5, R9: 1k; R_0805_2012Metric
R6: 2k; R_0805_2012Metric
R10: 100k; R_0805_2012Metric

Connections:
+3V3: J1.3, J6.1, Q1.1 (G), Q2.1 (G), R1.1, R3.1
+5V: A1.27 (+5V), C1.1, C2.1, J1.1, J2.3, J8.2, R2.1, R4.1
/CHG_EN: A1.22 (A3), J5.1
/HV_SENSE: A1.21 (A2), J5.2
/IR_CLK: A1.16 (D13), J2.2
/IR_DATA: A1.15 (D12), J2.4
/IR_LOAD: A1.19 (A0), J2.1
/KICK: A1.20 (A1), J5.3
/LINE: A1.25 (A6), J8.1
/M1_DIR: A1.5 (D2), J3.1
/M1_PWM: A1.6 (D3), J3.2
/M2_DIR: A1.7 (D4), J3.3
/M2_PWM: A1.8 (D5), J3.4
/M3_DIR: A1.10 (D7), J4.2
/M3_PWM: A1.9 (D6), J4.1
/M4_DIR: A1.13 (D10), J4.4
/M4_PWM: A1.12 (D9), J4.3
/REF_IN: A1.11 (D8), R9.2, R10.1
/REF_PIN: J9.1, R9.1
/SCL_3V3: J6.2, Q2.2 (S), R3.2
/SCL_5V: A1.24 (A5), Q2.3 (D), R4.2
/SDA_3V3: J6.3, Q1.2 (S), R1.2
/SDA_5V: A1.23 (A4), Q1.3 (D), R2.2
/UART_RX: A1.2 (D0/RX), J7.2
/UART_TX: A1.1 (D1/TX), R5.1
/UART_TX_3V3: J7.1, R5.2, R6.1
/VBAT_SENSE: A1.26 (A7), J1.2
GND: A1.4 (GND), A1.29 (GND), C1.2, C2.2, J1.4, J2.5, J3.5, J4.5, J5.4, J6.4, J7.3, J8.3, J9.2, R6.2, R10.2

Notes on the sheet:
1. マイコン（Arduino Nano 形）
2. コネクタ
3. I2C のレベル変換（5 V ↔ 3.3 V）
IMU モジュールのピン順は製品ごとに違う。必ず確かめる
4. UART（CoreS3 へ）
5 V × 2k/(1k+2k) ≒ 3.3 V

Board: 2 copper layers, 102.0 x 60.0 mm, 26 parts (0 on the bottom side), 28 nets.

## KiCad design kicad/power/power.kicad_pcb

Parts:
C1: 470uF 25V; CP_Radial_D10.0mm_P5.00mm
C2, C7: 0.1uF; C_0805_2012Metric
C3: 10uF 25V; C_1206_3216Metric
C4: 22uF 10V; C_1206_3216Metric
C5, C6: 1uF; C_0805_2012Metric
D1: 15V; D_SOD-123
D2: 緑; LED_0805_2012Metric
F1: 10A ミニ平型; Fuse_Blade_Mini_directSolder
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: 電池入力 XT30(オス); AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: 電源スイッチへ (XH 2P); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: モータ基板へ XT30(メス); AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J4: メイン基板へ (XH 4P); JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J5: キッカー基板へ (XH 2P); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Q1: P-MOSFET 40V (DPAK); TO-252-2
R1, R2: 100k; R_0805_2012Metric
R3: 33k; R_0805_2012Metric
R4: 1k; R_0805_2012Metric
TP1: VBAT; TestPoint_Loop_D2.50mm_Drill1.0mm
TP2: GND; TestPoint_Loop_D2.50mm_Drill1.0mm
TP3: +5V; TestPoint_Loop_D2.50mm_Drill1.0mm
U1: R-78E5.0-1.0; Converter_DCDC_RECOM_R-78E-0.5_THT
U2: AP2112K-3.3; SOT-23-5

Connections:
+3V3: C6.1, J4.3, U2.5 (VOUT)
+5V: C4.1, C5.1, J4.1, R4.1, TP3.1, U1.3 (OUT), U2.1 (VIN), U2.3 (EN)
/LED_PWR: D2.2 (A), R4.2
/Q1_G: D1.2 (A), Q1.1 (G), R1.1
/VBAT: C1.1, C2.1, C3.1, D1.1 (K), J3.2, J5.1, Q1.3 (S), R2.1, TP1.1, U1.1 (IN)
/VBAT_F: F1.2, Q1.2 (D)
/VBAT_IN: J1.2, J2.1
/VBAT_SENSE: C7.1, J4.2, R2.2, R3.1
/VBAT_SW: F1.1, J2.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D2.1 (K), J1.1, J3.1, J4.4, J5.2, R1.2, R3.2, TP2.1, U1.2 (GND), U2.2 (GND)

Notes on the sheet:
1. 入力と保護
2. 5 V（スイッチング）
3. 3.3 V（LDO）
4. 電池電圧の監視
12.6 V × 33/(100+33) ≒ 3.13 V
5. 出力コネクタ
6. 検査用の測定点
XT30 のフットプリントは 1 番ピンが「−」、2 番ピンが「＋」

Board: 2 copper layers, 70.0 x 50.0 mm, 29 parts (0 on the bottom side), 10 nets.
