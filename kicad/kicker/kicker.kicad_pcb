# Repository Asg1223/rcj-circuit (continued)

## KiCad design kicad/motor/motor.kicad_pcb

Parts:
C1, C2, C3, C4: 0.1uF 50V; C_0805_2012Metric
C5, C6, C7, C8: 10uF 25V; C_1206_3216Metric
C9: 470uF 25V; CP_Radial_D10.0mm_P5.00mm
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: 電源基板から XT30(オス); AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J2: メイン基板 J3 から (XH 5P); JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J3: メイン基板 J4 から (XH 5P); JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J4: モータ 1 (XH 2P); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5: モータ 2 (XH 2P); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: モータ 3 (XH 2P); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J7: モータ 4 (XH 2P); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
R1, R2, R3, R4: 32k; R_0805_2012Metric
U1, U2, U3, U4: DRV8871DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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

Connections:
/ILIM1: R1.1, U1.4 (ILIM)
/ILIM2: R2.1, U2.4 (ILIM)
/ILIM3: R3.1, U3.4 (ILIM)
/ILIM4: R4.1, U4.4 (ILIM)
/M1_DIR: J2.1, U1.3 (IN1)
/M1_OUT1: J4.1, U1.6 (OUT1)
/M1_OUT2: J4.2, U1.8 (OUT2)
/M1_PWM: J2.2, U1.2 (IN2)
/M2_DIR: J2.3, U2.3 (IN1)
/M2_OUT1: J5.1, U2.6 (OUT1)
/M2_OUT2: J5.2, U2.8 (OUT2)
/M2_PWM: J2.4, U2.2 (IN2)
/M3_DIR: J3.2, U3.3 (IN1)
/M3_OUT1: J6.1, U3.6 (OUT1)
/M3_OUT2: J6.2, U3.8 (OUT2)
/M3_PWM: J3.1, U3.2 (IN2)
/M4_DIR: J3.4, U4.3 (IN1)
/M4_OUT1: J7.1, U4.6 (OUT1)
/M4_OUT2: J7.2, U4.8 (OUT2)
/M4_PWM: J3.3, U4.2 (IN2)
/VBAT: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, J1.2, U1.5 (VM), U2.5 (VM), U3.5 (VM), U4.5 (VM)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, J1.1, J2.5, J3.5, R1.2, R2.2, R3.2, R4.2, U1.1 (GND), U1.7 (GND), U1.9 (GND), U2.1 (GND), U2.7 (GND), U2.9 (GND), U3.1 (GND), U3.7 (GND), U3.9 (GND), U4.1 (GND), U4.7 (GND), U4.9 (GND)

Notes on the sheet:
モータ 1
モータ 2
モータ 3
モータ 4

Board: 2 copper layers, 102.0 x 46.0 mm, 28 parts (0 on the bottom side), 22 nets.
